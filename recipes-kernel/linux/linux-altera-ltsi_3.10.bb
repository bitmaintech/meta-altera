DTB_SUBDIR="dts/"

KERNEL_REPO="git://at-git/linux-bringup.git"
KERNEL_BRANCH="socfpga-3.10.31-ltsi"
KERNEL_PROT="git"

require recipes-kernel/linux/linux-altera.inc

