DTB_SUBDIR="dts/"

KERNEL_REPO="git://at-git/linux-bringup.git"
KERNEL_PROT="git"

require recipes-kernel/linux/linux-altera-ltsi.inc

