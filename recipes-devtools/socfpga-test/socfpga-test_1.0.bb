require recipes-devtool/socfpga-test/socfpga.inc
